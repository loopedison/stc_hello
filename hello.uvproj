# Keil uVision project hello.uvproj, settings and files
target hello (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: hello +hex
  c flags: Optimize=9 SizeSpeed=1
  group main
    ./Sources/: main.c timer.c uart.c shell.c adc.c key.c led.c app.c
